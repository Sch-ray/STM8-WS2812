# IAR project GPIO.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 2
  General.GenDataModel: 2
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: ; STM8S_StdPeriph_Driver\src; STM8S_StdPeriph_Driver\inc; other libary
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.srec
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  General.GenDataModel: 1
  ICCSTM8.CCDefines: NDEBUG
  group my-libary
    other libary/: Adc.c Adc.h Bluetooth.c Bluetooth.h DS1302.c DS1302.h LED.c LED.h Tool.c Tool.h
  group StdPeriph_Driver
    ../STM8-433MHz射频设备/STM8S_StdPeriph_Driver/src/: stm8s_adc1.c
    STM8S_StdPeriph_Driver/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_uart1.c
    ./: stm8s_it.c
  group user
    ./: main.c stm8s_conf.h stm8s_it.h
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_clk.h stm8s_gpio.h stm8s_tim2.h stm8s_uart1.h
    ../STM8-433MHz射频设备/STM8S_StdPeriph_Driver/inc/: stm8s_adc1.h
